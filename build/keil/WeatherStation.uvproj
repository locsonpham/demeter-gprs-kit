# Keil uVision project WeatherStation.uvproj, settings and files
target ZoneControl (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Agri +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F4XX,HSE_VALUE = 8000000
  c misc: --c99
  c include: .\User;.\Src;..\F4Lib\CMSIS\Device\ST\STM32F4xx\Include;..\F4Lib\CMSIS\Device\ST\STM32F4xx\Source\Templates\arm;..\F4Lib\STM32F4xx_StdPeriph_Driver\inc;.\Src\fatfs;.\Src\fatfs\option;.\Src\gsm;.\Src\hc05;.\Src\rf433;.\Src\rs232;.\Src\rs485;.\Src\ethernet\inc;.\Src\freemodbus\modbus;.\Src\freemodbus\modbus\ascii;.\Src\freemodbus\modbus\rtu;.\Src\freemodbus\modbus\tcp;.\Src\freemodbus\modbus\include;.\Src\freemodbus\port;.\Src\freemodbus;.\Src\glcd_u8g;.\Src\glcd_u8g\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group SYS
    ../F4Lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
    ../F4Lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group User
    ./User/: main.c stm32f4xx_it.c system_stm32f4xx.c interrupt.h defines.h
    ./Src/: system_config.c
  group Src
    ./Src/: systick.c uart.c input.c output.c adc.c spi.c ringbuf.c m_time.c sys_time.c flash.c
  group Modbus
    ./Src/freemodbus/: mbhandler.c com.c comms.c
    ./Src/freemodbus/port/: portevent.c portserial.c porttimer.c
    ./Src/freemodbus/modbus/: mb.c
    ./Src/freemodbus/modbus/rtu/: mbcrc.c mbrtu.c
    ./Src/freemodbus/modbus/ascii/: mbascii.c
    ./Src/freemodbus/modbus/tcp/: mbtcp.c
    ./Src/freemodbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group rs232
    ./Src/rs232/: rs232_com.c
  group hc05
    ./Src/hc05/: hc05_com.c
  group ethernet
    ./Src/ethernet/src/: EtherShield.c enc28j60.c ip_arp_udp_tcp.c dhcp.c dnslkup.c websrv_help_functions.c
  group sdcard
    ./Src/fatfs/: ff.c sdcard.c fattime.c
  group gsm
    ./Src/gsm/: modem.c sim900.c at_command_parser.c gsm_handler.c
  group lcd
    ./Src/glcd_u8g/: u8g_arm.c bitmap.c
    ./Src/glcd_u8g/src/: chessengine.c u8g_bitmap.c u8g_circle.c u8g_clip.c u8g_com_api.c u8g_com_api_16gr.c u8g_com_i2c.c u8g_com_io.c u8g_com_null.c u8g_cursor.c u8g_delay.c u8g_dev_st7920_128x64.c u8g_ellipse.c u8g_font.c u8g_font_data.c u8g_line.c u8g_ll_api.c u8g_page.c u8g_pb.c u8g_pb8h1.c u8g_pb8h1f.c u8g_pb8h2.c u8g_pb8h8.c u8g_pb8v1.c u8g_pb8v2.c u8g_pb14v1.c u8g_pb16h1.c u8g_pb16h2.c u8g_pb16v1.c u8g_pb16v2.c u8g_pb32h1.c u8g_pbxh16.c u8g_pbxh24.c u8g_polygon.c u8g_rect.c u8g_rot.c u8g_scale.c u8g_state.c u8g_u8toa.c u8g_u16toa.c u8g_virtual_screen.c
